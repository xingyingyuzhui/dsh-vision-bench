# Keil uVision project includes-and-defines.uvprojx, settings and files
target TestTarget ()
  c define: STM32F40_41xxx; USE_HAL_DRIVER, VECT_TAB_FLASH
  c include: .\inc;.\lib\inc;..\common\inc
  group Drivers
    drivers/: driver.c
