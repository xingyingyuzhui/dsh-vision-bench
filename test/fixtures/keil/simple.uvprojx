# Keil uVision project simple.uvprojx, settings and files
target Debug ()
  output: simple_firmware
  c define: DEBUG,USE_STDPERIPH
  c include: inc;../outside
  group User
    src/: main.c
