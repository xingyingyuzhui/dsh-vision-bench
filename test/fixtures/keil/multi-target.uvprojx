# Keil uVision project multi-target.uvprojx, settings and files
target STM32F103_Flash ()
  output: fw_flash
  group App
    src/: app.c
target STM32F103_RAM ()
  output: fw_ram
